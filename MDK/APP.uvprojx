# Keil uVision project APP.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP +hex
  BeforeMake: conv dsp ../FW/DSP.ldr ../DSP.bin
  AfterMake: fromelf --bin --output ../FW/APP.bin OBJS/APP.axf
  AfterMake: conv mcu ../FW/APP.bin ../MCU.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,APP
  c include: ../User/inc;../User/USB/inc;../User/task;../Os/RTX5;../Driver/stm32f10x/sys;../Driver/stm32f10x/drv/inc
  asm include: ./Os;./Usr/inc;./Usb/inc;./Driver/sys;./Driver/drv/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Task
    ../User/task/: main.c dev.c com.c gui.c
  group User
    ../User/src/: adc.c amp.c dac.c default.c delay.c dsp.c e2p.c fan.c font.c gpio.c hdmi.c hid.c i2c.c i2c2.c knob.c lcd.c mp25.c paras.c power.c queue.c rbuf.c sys.c tmr.c usart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f10x_it.c system_stm32f10x.c msg.c lock.c ir.c
  group Usb
    ../User/USB/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Driver
    ../Driver/stm32f10x/drv/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Driver/stm32f10x/sys/: startup_stm32f10x_hd.s
  group Os
    ../Os/RTX5/: irq_cm3.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c RTX_Config.h
